GNU_SOURCE = "http://mirror.switch.ch/ftp/mirror/gnu"
KERNEL_SOURCES = "https://www.kernel.org/pub/linux/kernel"
